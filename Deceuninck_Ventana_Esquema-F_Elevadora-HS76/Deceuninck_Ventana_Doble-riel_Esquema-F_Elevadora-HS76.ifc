Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-12-22T11:41:07
Author: Scarlett Alday, s.aldayaranda@gmail.com
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Dec 22 11:41:07 2023 * Host: LAPTOP-VOCR0U39 * Database: C:\Users\salda\AppData\Local\Temp\4ce67168-e4ba-47bd-b539-a9c34c494968\e43064f8-7f14-4148-8aa0-978b0872164c\ifc * Database version: 5507 * Database creation date: Fri Dec 22 11:41:07 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Dec 22 11:41:07 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Dec 22 11:41:07 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: Deceuninck_Ventana_Esquema-F_Elevadora-HS76:Deceuninck_Ventana_Esquema-F_Elevadora-HS76, Deceuninck_Ventana_Esquema-F_Elevadora-HS76:Deceuninck_Ventana_Esquema-F_Elevadora-HS76:598602
In: Level 1
Type - Classification: B2020100 Windows (Uniformat); Material: PVC, Aluminium, Deceuninck - 1.White/PVC, Galvanized steel, Glass
Type - Analytical Properties - Analytic Construction: <None>; Define Thermal Properties by: Schematic Type
Type - Construction - Wall Closure: By host
Type - Dimensions - Construction Height: 3005 mm; Construction Width: 6005 mm; Frame Fit: 77 mm; Gap: 15 mm; Glass Height: 2676 mm; Glass Width: 5838 mm; Height: 3000 mm; Max. Sash Height: 3000 mm; Max. Sash Width: 6500 mm; Offset: 100 mm; Rough Height: 2846 mm; Sash Fit: 3 mm; Width: 6000 mm
Type - Identity Data - Assembly Code: B2020100; Assembly Description: Windows; Constructive depth: 175mm; C-Section Model: https://skfb.ly/oFFT6; Glass Type: Monolitic, laminated, thermopanel; Glazing capacity: 4 a 44mm; Internacional Certification: ISO 9001-ISO 14001-BS OHSAS 18001 approved by TUV Rheiland; Line: Elevadora HS-76; Maintenance: https://deceuninck.cl/pdf/mantencion.pdf; Manufacturer: Deceuninck; Model: F SCHEMA; OmniClass Number: 23.30.20.00; OmniClass Title: Windows; Opening: Sliding; Panels: 4 sliding; Rail Type: Double rail; Technical Area: info@deceuninckbim.cl; Type Comments: Calculations made based on load of 500 Pa (103km/h); Type Mark: 105; Type Name: Deceuninck_Ventana_Esquema-F_Elevadora-HS76; URL: http://deceuninck.cl; Use: Interior
Type - Materials and Finishes - Available colours: https://deceuninckbim.cl/pdf/fichas/Elevadora-esq-f.pdf; Frame: Deceuninck - 1.White/PVC; Handle: PVC; Rail: Aluminium; Reinforcement: Galvanized steel; Sash: Deceuninck - 1.White/PVC
Type - Model Properties - Acoustic insulation: Rw=33 (-1;-4) dB according to ISO 140-3, ISO 717 **; Air permeability: Class 4 according to EN 12207; Fire reaction: Class C-s3, d2 according EN 13501-1; Max. Sash surface: 13 m2; Water tightness: Class 4A according to EN 12208; Wind load resistance: Class C2/B3 according to EN 12210
Type - Other - Category: Windows; Altura de antepecho por defecto: 0 mm; Family Name: Deceuninck_Ventana_Esquema-F_Elevadora-HS76
Type - Pset_ManufacturerTypeInformation - Manufacturer: Deceuninck
Type - Pset_ProductRequirements - Category: Windows
Type - Pset_ProvisionForVoid - Width: 6000 mm; Height: 3000 mm
Material: Glass, Deceuninck - 1.White/PVC
Pset_BuildingElementProxyCommon - Reference: Deceuninck_Ventana_Esquema-F_Elevadora-HS76; sets with these values: 2
Constraints - Level: Level: Level 1; Sill Height: 0 mm
Dimensions - Area: 42.5905 m2; Volume: 0.467027 m3
Identity Data - Mark: 94
Other - Family: Deceuninck_Ventana_Esquema-F_Elevadora-HS76: Deceuninck_Ventana_Esquema-F_Elevadora-HS76; Family and Type: Deceuninck_Ventana_Esquema-F_Elevadora-HS76: Deceuninck_Ventana_Esquema-F_Elevadora-HS76; Head Height: 3000 mm; Host Id: Basic Wall: Generic - 200mm; ON_OFF - Height: no; ON_OFF - Width: no; Type: Deceuninck_Ventana_Esquema-F_Elevadora-HS76: Deceuninck_Ventana_Esquema-F_Elevadora-HS76; Type Id: Deceuninck_Ventana_Esquema-F_Elevadora-HS76: Deceuninck_Ventana_Esquema-F_Elevadora-HS76
Phasing - Phase Created: New Construction
